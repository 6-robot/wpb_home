Commit message: mani demo

File: wpb_home_bringup/urdf/wpb_home.urdf (robot description, URDF)
Before this commit: robot wp_v4, 7 links, 6 joints
Joints:
- joint kinect_height: origin xyz=0.174 0 0 rpy=0 -1.5707963 0 -> xyz=0.145 -0.013 0 rpy=0 -1.5707963 0
